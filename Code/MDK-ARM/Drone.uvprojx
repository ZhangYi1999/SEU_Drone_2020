# Keil uVision project Drone.uvprojx, settings and files
target Drone (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Drone +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M
  c include: ..\Inc;           ..\Drivers\STM32F4xx_HAL_Driver\Inc;           ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;           ../Drivers/CMSIS/Include;           ../Middlewares/Third_Party/FreeRTOS/Source/include;           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;           ..\Task\Inc;           ..\System\Inc;           ..\OnboardMPU\Inc;           ..\Mathlib;           ..\System\Src;         ../Middlewares/Third_Party/FatFs/src
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ../System/Inc/: Sys_Config.h Sys_Def.h System.h
    ../System/Src/: System.c
  group Task
    ../Task/Inc/: Task_Init.h Task_Protect.h Task_Position.h Task_Judge.h Task_JetsonComm.h Task_RC.h Task_CanComm.h Task_StateMachine.h Task_Gimbal.h Task_Shoot.h Task_LED.h Task_Debug.h Task_Ui.h Task_SDIO.h Task_TOF.h
    ../Task/Src/: Task_Init.c Task_Protect.c Task_Position.c Task_Judge.c Task_JetsonComm.c Task_RC.c Task_CanComm.c Task_StateMachine.c Task_Gimbal.c Task_Shoot.c Task_LED.c Task_Debug.c Task_Ui.c Task_SDIO.c Task_TOF.c
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c freertos.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group OnboardMPU
    ../OnboardMPU/Inc/: Func_Imu_OB.h ist8310_reg.h mpu6500_reg.h
    ../OnboardMPU/Src/: Func_Imu_OB.c
  group Mathlib
    ../Mathlib/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
software components: CMSIS:CORE 4.3.0
